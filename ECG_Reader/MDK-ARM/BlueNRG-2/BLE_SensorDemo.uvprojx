# Keil uVision project BLE_SensorDemo.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IROM(0x10040000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_SensorDemo +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_SensorDemo.axf --output Release\Objects\BLE_SensorDemo.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c include: ..\..\inc;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\Stent_Sensor_Files
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group OTA
    ../../../../../Library/BLE_Application/OTA/src/: OTA_btl.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../src/: BlueNRG1_it.c gatt_db.c sensor.c SensorDemo_main.c
    ../../Stent_Sensor_Files/: Stent_Sensor_ADC.c Stent_Sensor_GPIO.c Stent_Sensor_Timer.c
target LowerApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BLE_SensorDemo_LowerApp_OTA +hex
  AfterMake: fromelf.exe --bin LowerApp_OTA\Objects\BLE_SensorDemo_LowerApp_OTA.axf --output LowerApp_OTA\Objects\BLE_SensorDemo_LowerApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH ST_OTA_LOWER_APPLICATION=1 BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1 OTA_EXTENDED_PACKET_LEN=1 BLE_STACK_CONFIGURATION=BLE_OTA_BASIC_CONFIGURATION
  c include: ..\..\inc;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine=-DST_OTA_LOWER_APPLICATION=1
target HigherApp_OTA (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BLE_SensorDemo_HigherApp_OTA +hex
  AfterMake: fromelf.exe --bin HigherApp_OTA\Objects\BLE_SensorDemo_HigherApp_OTA.axf --output HigherApp_OTA\Objects\BLE_SensorDemo_HigherApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH ST_OTA_HIGHER_APPLICATION=1 BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1 OTA_EXTENDED_PACKET_LEN=1 BLE_STACK_CONFIGURATION=BLE_OTA_BASIC_CONFIGURATION
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine=-DST_OTA_HIGHER_APPLICATION=1
target Use_OTA_ServiceManager (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BLE_SensorDemo_Use_OTA_ServiceManager +hex
  AfterMake: fromelf.exe --bin Use_OTA_ServiceManager\Objects\BLE_SensorDemo_Use_OTA_ServiceManager.axf --output Use_OTA_ServiceManager\Objects\BLE_SensorDemo_Use_OTA_ServiceManager.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1 BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine=-DST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
